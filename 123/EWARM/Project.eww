<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\projeto_final_grupo_g.ewp</path>
  </project>
  <batchBuild />
</workspace>
